# Keil uVision project GR5525_SmartWatch.uvprojx, settings and files
target GRxx_Soc (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: GR5525_SmartWatch +hex
  AfterMake: fromelf.exe --text -c --output Listings\@L.s   Objects\@L.axf
  AfterMake: fromelf.exe --bin --output Listings\@L.bin Objects\@L.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GR5526_SK,ENV_USE_FREERTOS,ENABLE_DFU_SPI_FLASH,DFU_V2,USE_EXTERNAL_RESOURCES=1 GR5625_SK
  c misc: --no-multibyte-chars --diag_error=warning
  c include: ..\Src\config;..\..\..\..\..\platform\include;..\..\..\..\..\platform\soc\include;..\..\..\..\..\platform\arch\arm\cortex-m\cmsis\core\include;..\..\..\..\..\platform\soc\linker\keil;..\..\..\..\..\platform\boards;..\..\..\..\..\components\libraries\app_graphics_mem;..\..\..\..\..\components\boards;..\..\..\..\..\components\drivers_ext\gr55xx;..\..\..\..\..\components\drivers_ext\st7735;..\..\..\..\..\components\drivers_ext\vs1005;..\..\..\..\..\components\libraries\app_alarm;..\..\..\..\..\components\libraries\app_assert;..\..\..\..\..\components\libraries\app_error;..\..\..\..\..\components\libraries\app_key;..\..\..\..\..\components\libraries\app_log;..\..\..\..\..\components\libraries\app_queue;..\..\..\..\..\components\libraries\app_timer;..\..\..\..\..\components\libraries\at_cmd;..\..\..\..\..\components\libraries\dfu_master;..\..\..\..\..\components\libraries\dfu_port;..\..\..\..\..\components\libraries\gui;..\..\..\..\..\components\libraries\gui\gui_config;..\..\..\..\..\components\libraries\hal_flash;..\..\..\..\..\components\libraries\hci_uart;..\..\..\..\..\components\libraries\pmu_calibration;..\..\..\..\..\components\libraries\ring_buffer;..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\components\libraries\utility;..\..\..\..\..\components\patch\ind;..\..\..\..\..\components\profiles\ams_c;..\..\..\..\..\components\profiles\ancs_c;..\..\..\..\..\components\profiles\ans;..\..\..\..\..\components\profiles\ans_c;..\..\..\..\..\components\profiles\bas;..\..\..\..\..\components\profiles\bas_c;..\..\..\..\..\components\profiles\bcs;..\..\..\..\..\components\profiles\bps;..\..\..\..\..\components\profiles\common;..\..\..\..\..\components\profiles\cscs;..\..\..\..\..\components\profiles\cts;..\..\..\..\..\components\profiles\cts_c;..\..\..\..\..\components\profiles\dis;..\..\..\..\..\components\profiles\dis_c;..\..\..\..\..\components\profiles\gls;..\..\..\..\..\components\profiles\gus;..\..\..\..\..\components\profiles\gus_c;..\..\..\..\..\components\profiles\hids;..\..\..\..\..\components\profiles\hrrcps;..\..\..\..\..\components\profiles\hrs;..\..\..\..\..\components\profiles\hrs_c;..\..\..\..\..\components\profiles\hts;..\..\..\..\..\components\profiles\ias;..\..\..\..\..\components\profiles\lls;..\..\..\..\..\components\profiles\ndcs;..\..\..\..\..\components\profiles\otas;..\..\..\..\..\components\profiles\otas_c;..\..\..\..\..\components\profiles\pass;..\..\..\..\..\components\profiles\pass_c;..\..\..\..\..\components\profiles\pcs;..\..\..\..\..\components\profiles\rscs;..\..\..\..\..\components\profiles\rscs_c;..\..\..\..\..\components\profiles\rtus;..\..\..\..\..\components\profiles\sample;..\..\..\..\..\components\profiles\ths;..\..\..\..\..\components\profiles\ths_c;..\..\..\..\..\components\profiles\thscps;..\..\..\..\..\components\profiles\tps;..\..\..\..\..\components\profiles\wechat;..\..\..\..\..\components\sdk\;..\..\..\..\..\components\drivers_ext\graphics_dc;..\..\..\..\..\components\drivers_ext\qspi_device\;..\..\..\..\..\components\graphics\gfx\common\;..\..\..\..\..\components\graphics\gfx\common\mem;..\..\..\..\..\components\graphics\gfx\configure;..\..\..\..\..\components\graphics\gfx\include;..\..\..\..\..\components\graphics\gfx\include\tsi;..\..\..\..\..\components\graphics\gfx\include\tsi\common;..\..\..\..\..\components\graphics\gfx\include\tsi\hal_gdc;..\..\..\..\..\components\graphics\gfx\include\tsi\hal_gfx;..\..\..\..\..\components\graphics\gfx\hal_gdc;..\..\..\..\..\components\graphics\gfx\hal_gfx;..\..\..\..\..\components\graphics\gfx\porting;..\..\..\..\..\components\libraries\app_graphics_mem;..\..\..\..\..\components\libraries\bt;..\..\..\..\..\components\libraries\bt_v2;..\..\..\..\..\components\libraries\fault_trace;..\..\..\..\..\drivers\inc;..\..\..\..\..\drivers\inc\hal;..\..\..\..\..\external\freertos\include;..\..\..\..\..\external\freertos\portable\RVDS\ARM_CM4F;..\..\..\..\..\external\segger_rtt;..\Src\lvgl_831;..\Src\lvgl_831\src;..\Src\lvgl_831\src\core;..\Src\lvgl_831\src\draw;..\Src\lvgl_831\src\draw\sw;..\Src\lvgl_831\src\extra;..\Src\lvgl_831\src\extra\layouts;..\Src\lvgl_831\src\extra\layouts\flex;..\Src\lvgl_831\src\extra\layouts\grid;..\Src\lvgl_831\src\extra\libs;..\Src\lvgl_831\src\extra\libs\bmp;..\Src\lvgl_831\src\extra\libs\freetype;..\Src\lvgl_831\src\extra\libs\fsdrv;..\Src\lvgl_831\src\extra\libs\gif;..\Src\lvgl_831\src\extra\libs\png;..\Src\lvgl_831\src\extra\libs\qrcode;..\Src\lvgl_831\src\extra\libs\rlottie;..\Src\lvgl_831\src\extra\libs\sjpg;..\Src\lvgl_831\src\extra\others;..\Src\lvgl_831\src\extra\others\snapshot;..\Src\lvgl_831\src\extra\themes;..\Src\lvgl_831\src\extra\themes\basic;..\Src\lvgl_831\src\extra\themes\default;..\Src\lvgl_831\src\extra\themes\mono;..\Src\lvgl_831\src\extra\widgets;..\Src\lvgl_831\src\extra\widgets\animimg;..\Src\lvgl_831\src\extra\widgets\calendar;..\Src\lvgl_831\src\extra\widgets\chart;..\Src\lvgl_831\src\extra\widgets\colorwheel;..\Src\lvgl_831\src\extra\widgets\imgbtn;..\Src\lvgl_831\src\extra\widgets\keyboard;..\Src\lvgl_831\src\extra\widgets\led;..\Src\lvgl_831\src\extra\widgets\list;..\Src\lvgl_831\src\extra\widgets\menu;..\Src\lvgl_831\src\extra\widgets\meter;..\Src\lvgl_831\src\extra\widgets\msgbox;..\Src\lvgl_831\src\extra\widgets\span;..\Src\lvgl_831\src\extra\widgets\spinbox;..\Src\lvgl_831\src\extra\widgets\spinner;..\Src\lvgl_831\src\extra\widgets\tabview;..\Src\lvgl_831\src\extra\widgets\tileview;..\Src\lvgl_831\src\extra\widgets\win;..\Src\lvgl_831\src\font;..\Src\lvgl_831\src\misc;..\Src\lvgl_831\src\widgets;..\Src\lvgl_831\src\hal;..\Src\lvgl_831\src\gpu;..\Src\lvgl_831\src\gpu\goodix;..\Src\lvgl_831\src\gpu\gr552x\porting;..\Src\app_font;..\Src\app_image;..\Src\app_layout;..\Src\app_main;..\Src\app_profiles;..\Src\app_tasks;..\Src\config;..\Src\dev_drivers;..\Src\lvgl_port;..\Src\system
  memory RVCT4: ROM 0x38000 size 0x28000
  memory RVCT9: RAM 0x2000a000 size 0x36000
  scatter file: ..\Src\linker\flash_scatter_graphics.sct
  link misc: ..\..\..\..\..\platform\soc\linker\keil\rom_symbol.txt
  group gr_startup
    ../../../../../platform/arch/arm/cortex-m/keil/: Startup.S
  group gr_arch
    ../../../../../platform/soc/common/: gr_system.c gr_interrupt.c gr_platform.c
  group gr_soc
    ../../../../../platform/soc/src/: gr_soc.c
  group gr_board
    ../../../../../platform/boards/: board_SK.c
  group gr_stack_lib
    ../../../../../platform/soc/linker/keil/: ble_sdk.lib
  group gr_app_drivers
    ../../../../../drivers/src/: app_dma.c app_gpiote.c app_io.c app_pwr_mgmt.c app_uart.c app_rtos_cfg.c app_qspi.c app_qspi_dma.c app_i2c.c app_i2c_dma.c app_graphics_qspi.c app_dual_tim.c app_uart_dma.c app_tim.c app_spi.c app_spi_dma.c
    ../../../../../components/libraries/fault_trace/: fault_trace.c
  group gr_drivers_ext
    ../../../../../components/drivers_ext/gr55xx/: gr55xx_spi_flash.c
  group gr_libraries
    ../../../../../components/libraries/utility/: utility.c
    ../../../../../components/libraries/app_timer/: app_timer.c
    ../../../../../components/libraries/ring_buffer/: ring_buffer.c
    ../../../../../components/libraries/pmu_calibration/: pmu_calibration.c
    ../../../../../components/libraries/app_log/: app_log.c
    ../../../../../components/libraries/app_error/: app_error.c
    ../../../../../components/libraries/app_assert/: app_assert.c
    ../../../../../components/libraries/app_key/: app_key.c app_key_core.c
    ../../../../../drivers/src/: app_rtc.c
    ../../../../../components/libraries/dfu_port/: dfu_port.c
  group freertos
    ../../../../../external/freertos/portable/GR55XX/: port_pm.c
    ../../../../../external/freertos/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../external/freertos/: timers.c tasks.c stream_buffer.c queue.c list.c heap_4.c event_groups.c croutine.c
  group bt_api
    ../../../../../components/libraries/bt_v2/: bt_api.c bt_api_impl.c bt_ifce.c
    ../../../../../components/libraries/bt/: bt_ctl_ota_interface.c bt_ctl_debug_interface.c
  group lvgl_src_core
    ../Src/lvgl_831/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl_src_draw
    ../Src/lvgl_831/src/draw/: lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c lv_draw.c lv_draw_layer.c lv_draw_transform.c
  group lvgl_src_draw_sw
    ../Src/lvgl_831/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group lvgl_src_extra
    ../Src/lvgl_831/src/extra/: lv_extra.c
    ../Src/lvgl_831/src/extra/layouts/flex/: lv_flex.c
    ../Src/lvgl_831/src/extra/layouts/grid/: lv_grid.c
    ../Src/lvgl_831/src/extra/themes/basic/: lv_theme_basic.c
    ../Src/lvgl_831/src/extra/themes/default/: lv_theme_default.c
    ../Src/lvgl_831/src/extra/themes/mono/: lv_theme_mono.c
    ../Src/lvgl_831/src/extra/widgets/animimg/: lv_animimg.c
    ../Src/lvgl_831/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Src/lvgl_831/src/extra/widgets/chart/: lv_chart.c
    ../Src/lvgl_831/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Src/lvgl_831/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Src/lvgl_831/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Src/lvgl_831/src/extra/widgets/led/: lv_led.c
    ../Src/lvgl_831/src/extra/widgets/list/: lv_list.c
    ../Src/lvgl_831/src/extra/widgets/menu/: lv_menu.c
    ../Src/lvgl_831/src/extra/widgets/meter/: lv_meter.c
    ../Src/lvgl_831/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Src/lvgl_831/src/extra/widgets/span/: lv_span.c
    ../Src/lvgl_831/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Src/lvgl_831/src/extra/widgets/spinner/: lv_spinner.c
    ../Src/lvgl_831/src/extra/widgets/tabview/: lv_tabview.c
    ../Src/lvgl_831/src/extra/widgets/tileview/: lv_tileview.c lv_fast_tileview.c
    ../Src/lvgl_831/src/extra/widgets/win/: lv_win.c
  group lvgl_src_font
    ../Src/lvgl_831/src/font/: lv_font.c lv_font_fmt_txt.c lv_font_loader.c
  group lvgl_src_hal
    ../Src/lvgl_831/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl_src_misc
    ../Src/lvgl_831/src/misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl_src_widgets
    ../Src/lvgl_831/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group lvgl_optimize
    ../Src/lvgl_831_optimize/: opt_lv_draw_label.c opt_lv_draw_sw_letter.c opt_lv_font.c opt_lv_indev_scroll.c opt_lv_obj.c opt_lv_obj_pos.c opt_lv_obj_style_gen.c opt_lv_refr.c
  group lvgl_port
    ../Src/lvgl_port/: lv_port_disp.c lv_port_disp.h lv_port_fs.c lv_port_fs.h lv_port_indev.c lv_port_indev.h lv_port_dma.c lv_port_dma.h lv_port_gximg.c
  group app_main
    ../Src/app_main/: main.c user_app.c
  group app_tasks
    ../Src/app_tasks/: app_lvgl_task.c bt_music_controller.c bt_phonecall_controller.c bt_conn_controller.c app_ota_task.c app_bt.c
  group app_layout
    ../Src/app_layout/: lv_layout_router.c lv_ecg_control_layout.c test_list.c lv_layout_tv_top.c lv_layout_tv_bottom.c lv_layout_tv_left.c lv_layout_tv_right.c lv_layout_tv_middle.c lv_activity_layout.c lv_status_layout.c lv_imgdigits.c lv_notification_layout.c lv_app_list_layout.c lv_simplified_obj.c lv_watchface_layout.c lv_ota_layout.c lv_list_entry_layout.c lv_heartrate_layout.c lv_heartrate_chart_layout.c lv_gx_chart.c watchface_manager.c lv_watchface_vivid_layout.c lv_watchface_digital_layout.c lv_watchface_black_layout.c lv_watchface_switch_layout.c lv_bt_manage_layout.c lv_bt_scan_device_layout.c lv_bt_pair_device_layout.c lv_bt_paired_device_layout.c lv_bt_remove_device_layout.c lv_bt_device_layout.c lv_img_rgb565.c lv_img_gximg.c lv_bt_dial_layout.c lv_bt_phonecall_layout.c lv_general_list_generator.c lv_general_options_page_generator.c lv_bt_ota_layout.c lv_bt_contact_layout.c lv_virtual_list.c lv_bt_calling_layout.c lv_bt_incoming_call_layout.c lv_bt_music_layout.c lv_volume_ctrl.c lv_bt_discovery_layout.c lv_bt_reconn_times_layout.c lv_bt_disconnect_layout.c lv_bt_reconn_times_confirm_layout.c lv_bt_no_entry_layout.c lv_bt_local_audio_layout.c lv_bt_factory_reset_layout.c
  group app_font
    ../Src/lvgl_831/src/font/: lv_font_montserrat_20.c lv_font_montserrat_40.c lv_font_montserrat_28.c
  group app_image
    ../Src/app_image/: lv_img_dsc_list.c binary_resources.c
  group app_profiles
    ../../../../../components/profiles/otas/: otas.c
    ../../../../../components/profiles/common/: ble_prf_utils.c
  group dev_drivers
    ../../../../../components/drivers_ext/qspi_device/: qspi_flash.c
    ../Src/dev_drivers/: display_crtl_drv.h display_crtl_drv.c bsp_tp.c bsp_tp.h tp_config.c tp_config.h flash_driver.c display_fls_amo139_360p_qspi_drv.h display_fls_amo139_360p_qspi_drv.c
  group system
    ../Src/system/: user_periph_setup.c system_manager.c system_manager.h
